# Keil uVision project ch552g_uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch552g_uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 CH552.H CH552_GPIO.c CH552_GPIO.h main.c CH552_FIFO.c CH552_FIFO.h CH552_UART.c CH552_UART.h CH552_RCC.c CH552_RCC.h
