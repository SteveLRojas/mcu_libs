# Keil uVision project ch552_hid_consumer_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch552_hid_consumer_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH552.H CH552_FIFO.c CH552_FIFO.h CH552_GPIO.c CH552_GPIO.h CH552_TIMER.c CH552_TIMER.h CH552_UART.c CH552_UART.h CH552_USB.c CH552_USB.h main.c System.c System.h usb_consumer_control.c usb_consumer_control.h
