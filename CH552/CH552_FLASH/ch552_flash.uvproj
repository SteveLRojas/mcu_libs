# Keil uVision project ch552_flash.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch552_flash +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH552.H CH552_GPIO.c CH552_GPIO.h CH552_TIMER.c CH552_TIMER.h CH552_USB.c CH552_USB.h CH552_USB_CDC.c CH552_USB_CDC.h main.c pseudo_random.c pseudo_random.h CH552_FLASH.c CH552_FLASH.h CH552_RCC.c CH552_RCC.h
