# Keil uVision project ch552g_i2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch552g_i2c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH552.H CH552_GPIO.c CH552_GPIO.h main.c System.c System.h CH552_I2C.c CH552_I2C.h CH552_TIMER.c CH552_TIMER.h CH552_SPI.c CH552_SPI.h CH552_FIFO.c CH552_FIFO.h CH552_UART.c CH552_UART.h
