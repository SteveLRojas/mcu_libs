# Keil uVision project ch547_flash.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH547 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: ch547_flash +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 CH547.H CH547_GPIO.c CH547_GPIO.h CH547_RCC.c CH547_RCC.h CH547_TIMER.c CH547_TIMER.h CH547_USB.c CH547_USB.h CH547_USB_CDC.c CH547_USB_CDC.h main.c CH547_FLASH.c CH547_FLASH.h pseudo_random.c pseudo_random.h
