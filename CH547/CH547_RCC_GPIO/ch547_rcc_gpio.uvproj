# Keil uVision project ch547_rcc_gpio.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH547 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: ch547_rcc_gpio +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH547_RCC.c CH547_RCC.h CH547.H CH547_GPIO.c CH547_GPIO.h main.c
