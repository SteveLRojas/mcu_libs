# Keil uVision project ch559_usb_test_host.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: ch559_usb_test_host +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH559.H CH559_FIFO.c CH559_FIFO.h CH559_GPIO.c CH559_GPIO.h CH559_RCC.c CH559_RCC.h CH559_TIMER.c CH559_TIMER.h CH559_UART.c CH559_UART.h CH559_USB_HOST.c CH559_USB_HOST.h main.c
