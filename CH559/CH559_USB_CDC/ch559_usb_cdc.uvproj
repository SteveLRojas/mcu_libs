# Keil uVision project ch559_usb_cdc.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: ch559_usb_cdc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH559.H CH559_FIFO.c CH559_FIFO.h CH559_GPIO.c CH559_GPIO.h CH559_TIMER.c CH559_TIMER.h CH559_UART.c CH559_UART.h DEBUG.C DEBUG.H main.c CH559_USB.c CH559_USB.h CH559_USB_CDC.c CH559_USB_CDC.h
