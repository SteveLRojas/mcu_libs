# Keil uVision project ch559_uc1701.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: ch559_uc1701 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH559_GPIO.c CH559_GPIO.h CH559_LED.c CH559_LED.h CH559_RCC.c CH559_RCC.h CH559_SPI.c CH559_SPI.h CH559_TIMER.c CH559_TIMER.h CH559_USB_CDC.c CH559_USB_CDC.h main.c CH559_USB.c CH559_USB.h pseudo_random.c pseudo_random.h CH559_UC1701.c CH559_UC1701.h
