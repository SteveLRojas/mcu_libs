# Keil uVision project ch559_timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: ch559_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH559.H CH559_GPIO.c CH559_GPIO.h DEBUG.C DEBUG.H main.c CH559_TIMER.c CH559_TIMER.h
